v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} -410 -310 0 0 {name=p1 lab=Vinp}
C {devices/ipin.sym} -410 -270 0 0 {name=p2 lab=Vinm}
C {devices/ipin.sym} -410 -460 0 0 {name=p3 lab=AVDD}
C {devices/ipin.sym} -410 -420 0 0 {name=p4 lab=AGND}
C {devices/ipin.sym} -410 -190 0 0 {name=p5 lab=en}
C {devices/ipin.sym} -410 -150 0 0 {name=p6 lab=hyst[1:0]}
C {devices/ipin.sym} -410 -110 0 0 {name=p7 lab=trim[5:0]}
C {devices/opin.sym} -350 -290 0 0 {name=p10 lab=Vout}
C {devices/ipin.sym} -410 -500 0 0 {name=p11 lab=DVDD}
C {devices/ipin.sym} -410 -70 0 0 {name=p17 lab=ibias}
C {devices/ipin.sym} -410 -380 0 0 {name=p8 lab=DGND}
